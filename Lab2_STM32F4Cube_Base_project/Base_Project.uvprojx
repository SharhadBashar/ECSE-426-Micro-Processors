# Keil uVision project Base_Project.uvprojx, settings and files
target Lab 2 (ARM-ADS)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Base_Project
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32F407xx , HSE_VALUE=8000000, LSE_STARTUP_TIMEOUT=10000,ARM_MATH_CM4
  c include: .\Headers
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Files
    ./Sources/: main.c supporting_functions.c stm32f4xx_it.c gpio_example.c sysclk_config.c LED_Control.c 7_Segment_Display.c temperature.c adc_example.c kalman.c
  group Header
    ./Headers/: gpio_example.h stm32f4xx_it.h supporting_functions.h sysclk_config.h LED_Control.h 7_Segment_Display.h temperature.h adc_example.h kalman.h
software components: CMSIS:CORE 5.0.0, CMSIS:DSP 1.4.6, Compiler:I/O:STDOUT 1.1.0, Device:STM32Cube Framework:Classic 1.5.0, Device:STM32Cube HAL:ADC 1.5.0, Device:STM32Cube HAL:Common 1.5.0, Device:STM32Cube HAL:Cortex 1.5.0, Device:STM32Cube HAL:DMA 1.5.0, Device:STM32Cube HAL:Flash 1.5.0, Device:STM32Cube HAL:GPIO 1.5.0, Device:STM32Cube HAL:I2C 1.5.0, Device:STM32Cube HAL:I2S 1.5.0, Device:STM32Cube HAL:PWR 1.5.0, Device:STM32Cube HAL:RCC 1.5.0, Device:STM32Cube HAL:RTC 1.5.0, Device:STM32Cube HAL:SPI 1.5.0, Device:STM32Cube HAL:SRAM 1.5.0, Device:STM32Cube HAL:TIM 1.5.0, Device:STM32Cube HAL:UART 1.5.0, Device:STM32Cube HAL:USART 1.5.0, Device:Startup 2.5.0
