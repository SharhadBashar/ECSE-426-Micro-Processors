# Keil uVision project Base_Project.uvprojx, settings and files
target Lab 4 (ARM-ADS)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Base_Project
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32F407xx , HSE_VALUE=8000000, LSE_STARTUP_TIMEOUT=10000, ARM_MATH_CM4, __FPU_PRESENT = 1
  c include: .\Headers
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Files
    ./Sources/: supporting_functions.c main.c stm32f4xx_it.c sysclk_config.c
  group Accelerometer
    ./Sources/: Acc_thread.c LIS3DSH.c accelerometer.c
  group Temperature
    ./Sources/: Temp_thread.c temperature.c
  group Kalman
    ./Sources/: kalman.c
  group Key Pad
    ./Sources/: key_pad.c Kp_thread.c
  group Display
    ./Sources/: 7_segment_display.c Disp_thread.c
  group Timers
    ./Sources/: Timer.c
software components: CMSIS:CORE 4.3.0, CMSIS:DSP 1.4.6, CMSIS:RTOS:Keil RTX 4.80.0, Compiler:I/O:STDOUT 1.0.0, Device:STM32Cube Framework:Classic 1.4.2, Device:STM32Cube HAL:ADC 1.4.2, Device:STM32Cube HAL:Common 1.4.2, Device:STM32Cube HAL:Cortex 1.4.2, Device:STM32Cube HAL:DMA 1.4.2, Device:STM32Cube HAL:Flash 1.4.2, Device:STM32Cube HAL:GPIO 1.4.2, Device:STM32Cube HAL:I2C 1.4.2, Device:STM32Cube HAL:I2S 1.4.2, Device:STM32Cube HAL:PWR 1.4.2, Device:STM32Cube HAL:RCC 1.4.2, Device:STM32Cube HAL:RTC 1.4.2, Device:STM32Cube HAL:SPI 1.4.2, Device:STM32Cube HAL:SRAM 1.4.2, Device:STM32Cube HAL:TIM 1.4.2, Device:STM32Cube HAL:UART 1.4.2, Device:STM32Cube HAL:USART 1.4.2, Device:Startup 2.4.2
