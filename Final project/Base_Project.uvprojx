# Keil uVision project Base_Project.uvprojx, settings and files
target Application (ARM-ADS)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Base_Project
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32F407xx , HSE_VALUE=8000000, LSE_STARTUP_TIMEOUT=10000, ARM_MATH_CM4, __FPU_PRESENT
  c include: .\Headers
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User Code
    ./Sources/: main.c supporting_functions.c stm32f4xx_it.c sysclk_config.c mouse_thread.c interrupts.c acc.c display.c kalman_filter.c temperature.c keypad.c cc2500.c
  group Drivers
    ./Sources/: LIS3DSH.c
  group Middleware
    ./Sources/: USBD_User_HID_Mouse_0.c
  group Header
    ./Headers/: acc.h cc2500_settings.h display.h interrupts.h kalman_filter.h keypad.h LIS3DSH.h main.h mouse_thread.h stm32f4xx_it.h supporting_functions.h sysclk_config.h temperature.h cc2500.h
software components: CMSIS:CORE 5.0.0, CMSIS:DSP 1.4.6, CMSIS:RTOS:Keil RTX 4.81.0, USB:CORE 6.7.0, USB:Device 6.7.0, USB:Device:HID 6.7.0, CMSIS Driver:USB Device:Full-speed 2.15, Compiler:I/O:STDOUT 1.1.0, Device:STM32Cube Framework:Classic 1.5.0, Device:STM32Cube HAL:ADC 1.5.0, Device:STM32Cube HAL:Common 1.5.0, Device:STM32Cube HAL:Cortex 1.5.0, Device:STM32Cube HAL:DMA 1.5.0, Device:STM32Cube HAL:GPIO 1.5.0, Device:STM32Cube HAL:PWR 1.5.0, Device:STM32Cube HAL:RCC 1.5.0, Device:STM32Cube HAL:RTC 1.5.0, Device:STM32Cube HAL:SPI 1.5.0, Device:STM32Cube HAL:SRAM 1.5.0, Device:STM32Cube HAL:TIM 1.5.0, Device:STM32Cube HAL:UART 1.5.0, Device:STM32Cube HAL:USART 1.5.0, Device:Startup 2.5.0
