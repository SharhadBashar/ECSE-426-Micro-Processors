# Keil uVision project Base_Project.uvprojx, settings and files
target Lab 2 (ARM-ADS)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Base_Project
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32F407xx , HSE_VALUE=8000000, LSE_STARTUP_TIMEOUT=10000, ARM_MATH_CM4, __FPU_PRESENT=1
  c include: .\Headers
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Files
    ./Sources/: main.c supporting_functions.c sysclk_config.c piezo.c stm32f4xx_it.c fput_debug.c key_pad.c timer.c accelerometer.c 7_segment_display.c kalman.c
  group Accelerometer
    ./Headers/: LIS3DSH.h
    ./Sources/: LIS3DSH.c
  group Header
    ./Headers/: main.h stm32f4xx_it.h supporting_functions.h sysclk_config.h piezo.h key_pad.h timer.h accelerometer.h 7_segment_display.h kalman.h
software components: CMSIS:CORE 5.0.0, CMSIS:DSP 1.4.6, Compiler:I/O:STDOUT 1.1.0, Device:STM32Cube Framework:Classic 1.5.0, Device:STM32Cube HAL:ADC 1.5.0, Device:STM32Cube HAL:Common 1.5.0, Device:STM32Cube HAL:Cortex 1.5.0, Device:STM32Cube HAL:DMA 1.5.0, Device:STM32Cube HAL:Flash 1.5.0, Device:STM32Cube HAL:GPIO 1.5.0, Device:STM32Cube HAL:I2C 1.5.0, Device:STM32Cube HAL:I2S 1.5.0, Device:STM32Cube HAL:PWR 1.5.0, Device:STM32Cube HAL:RCC 1.5.0, Device:STM32Cube HAL:RTC 1.5.0, Device:STM32Cube HAL:SPI 1.5.0, Device:STM32Cube HAL:SRAM 1.5.0, Device:STM32Cube HAL:TIM 1.5.0, Device:STM32Cube HAL:UART 1.5.0, Device:STM32Cube HAL:USART 1.5.0, Device:Startup 2.5.0
